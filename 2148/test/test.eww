<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\iar\led.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\test.ewp</path>
  </project>
  <batchBuild/>
</workspace>


